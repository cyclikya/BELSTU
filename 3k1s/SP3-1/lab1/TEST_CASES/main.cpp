#include "tests.h"
#include <iostream>

int main()
{
    // Создаём хеш-таблицу
    HT::HTHandle* ht = HT::Create(1000, 3, 10, 256, L"HTspace.ht");
    if (ht)
        std::cout << "-- create: success" << std::endl;
    else {
        std::cerr << "-- create: error" << std::endl;
        return 1;
    }

    if (tests::test1(ht))
        std::cout << "-- test1: success" << std::endl;
    else
        std::cout << "-- test1: error" << std::endl;

    if (tests::test2(ht))
        std::cout << "-- test2: success" << std::endl;
    else
        std::cout << "-- test2: error" << std::endl;

    if (tests::test3(ht))
        std::cout << "-- test3: success" << std::endl;
    else
        std::cout << "-- test3: error" << std::endl;

    if (tests::test4(ht))
        std::cout << "-- test4: success" << std::endl;
    else
        std::cout << "-- test4: error" << std::endl;

    if (ht != nullptr) {
        if (HT::Close(ht))
            std::cout << "-- close: success" << std::endl;
        else
            std::cerr << "-- close: error" << std::endl;
    }

    return 0;
}
